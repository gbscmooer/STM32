# Keil uVision project STM32weather.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32weather +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Public;..\APP\esp8266;..\User;..\APP\lsens;..\APP\exti;..\APP\iwdg;..\APP\pwm;..\APP\time;..\APP\wwdg;..\APP\beep;..\APP\key;..\APP\led;..\APP\FREERTOS\include;..\APP\FREERTOS\portable\RVDS\ARM_CM3;..\APP\MQTT\source\include;..\APP\MQTT\source\interface;..\APP\adc_temp;..\APP\dht11;..\APP\TFTLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group APP
    ../APP/esp8266/: wifi_config.c wifi_function.c
    ../APP/lsens/: lsens.c
    ../APP/exti/: exti.c
    ../APP/iwdg/: iwdg.c
    ../APP/pwm/: pwm.c
    ../APP/time/: time.c
    ../APP/wwdg/: wwdg.c
    ../APP/beep/: beep.c
    ../APP/key/: key.c
    ../APP/led/: led.c
    ../APP/MQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
    ../APP/FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../APP/FREERTOS/portable/RVDS/ARM_CM3/: port.c
    ../APP/FREERTOS/portable/MemMang/: heap_4.c
    ../APP/adc_temp/: adc_temp.c
    ../APP/dht11/: dht11.c
    ../APP/TFTLCD/: tftlcd.c
  group User
    ../User/: main.c stm32f10x_it.c app_freertos.c mqtt_client.c
  group cJSON
    ../APP/cJSON/: cJSON.c
  group Public
    ../Public/: system.c SysTick.c usart.c
  group STM32StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
